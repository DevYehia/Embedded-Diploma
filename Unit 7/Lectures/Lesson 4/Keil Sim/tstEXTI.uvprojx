# Keil uVision project tstEXTI.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: tstEXTI
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3
  c include: .\UTIL;.\MCAL;..\Keil Sim
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Source Group 1
    ./: main.c stm32f103x8.h
    ./MCAL/: exti.c exti.h gpio.c gpio.h
    ./UTIL/: bitwise.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
