# Keil uVision project e2prom.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: e2prom
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group HAL
    ./HAL/: E2PROM.c E2PROM.h
  group MCAL
    ./MCAL/: gpio.c gpio.h i2c.c i2c.h rcc.c rcc.h
  group UTIL
    ./UTIL/: bitwise.h
  group Device Header
    ./Device Header/: stm32f103x8.h
  group App
    ./: main.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
